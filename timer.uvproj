# Keil uVision project timer.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: timer
  c flags: Optimize=8 SizeSpeed=1
  group Sources
    ./: timer.c
  group Headers
    ./: STC12C5620AD.H
